# Keil uVision project RobotPro.uvprojx, settings and files
target RobotPro (ARM-ADS)
  device: STM32F205RBTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RobotPro
  c flags: Optim=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER, USE_USB_OTG_FS
  c include: ..\uCOS-III;..\KeilMDK;..\BSP\OS\uCOS-III;..\BSP\STM32F2xx\inc;..\BSP\CMSIS\Device_Support;..\BSP\CMSIS;..\BSP\KeilMDK;..\BSP;..\uC-CPU\ARM-Cortex-M3;..\uC-CPU;..\uC-LIB\Ports\ARM-Cortex-M3;..\uC-LIB;..\uCOS-III\Source;..\uCOS-III\Ports\ARM-Cortex-M3;..\App;..\Fatfs;..\Fatfs\option;..\HardDrivers;..\BSP\CMSIS\Device_Support;..\USB_DeviceLIB\Class\cdc\inc;..\USB_DeviceLIB\Core\inc;..\USB_OTG_Driver\inc;..\USB_VCP;..\Xmodem;..\Helix\real;..\Helix\pub
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h pc_protocol.c pc_protocol.h servo_protocol.c servo_protocol.h mp3_player.c
  group BSP
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_ser.c bsp_ser.h bsp_sdio.c bsp_sdio.h cstartup.s bitband.h delay.c delay.h gpio.c gpio.h timer.c timer.h usart.c usart.h util.c util.h bsp_dac.c bsp_dac.h bsp_dma.c bsp_dma.h
    ../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group STM32F2xxLIB
    ../BSP/STM32F2xx/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../BSP/STM32F2xx/inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
  group uC-LIB
    ../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uC-LIB/Ports/ARM-Cortex-M3/: lib_mem_a.asm
  group uC-CPU
    ../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../uC-CPU/ARM-Cortex-M3/: cpu.h cpu_a.asm cpu_c.c
  group uCOS-III Ports
    ../uCOS-III/Ports/ARM-Cortex-M3/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS-III Source
    ../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group Fatfs
    ../Fatfs/: diskio.c ff.c
    ../Fatfs/option/: ccsbcs.c
  group DeviceSupport
    ../BSP/CMSIS/Device_Support/: stm32f2xx.h stm32f2xx_conf.h system_stm32f2xx.c system_stm32f2xx.h
  group USB_DeviceLIB
    ../USB_DeviceLIB/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB_DeviceLIB/Class/cdc/src/: usbd_cdc_core.c
  group USB_OTG_Driver
    ../USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_VCP
    ../USB_VCP/: usb_bsp.c usb_delay.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group Xmoderm
    ../Xmodem/: crc16.c crc16.h xmodem.c xmodem.h xmodem_hw.c xmodem_hw.h
  group Helix
    ../Helix/: mp3dec.c mp3tabs.c
    ../Helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c assembly.h coder.h
    ../Helix/real/arm/: asmmisc.s asmpoly_thumb2.s
